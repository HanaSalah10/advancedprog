<?xml version="1.0" encoding="UTF-8" standalone="no"?><AUTOSAR><CONTAINER UUID="198ae269-8478-44bd-92b5-14982c4ff68b"><SHORTNAME>ContainerA</SHORTNAME><LONGNAME>BB</LONGNAME></CONTAINER><CONTAINER UUID="198ae269-8478-44bd-92b5-14982c4ff68a"><SHORTNAME>ContainerB</SHORTNAME><LONGNAME>AA</LONGNAME></CONTAINER><CONTAINER UUID="198ae269-8478-44bd-92b5-14982c4ff68c"><SHORTNAME>ContainerC</SHORTNAME><LONGNAME>CC</LONGNAME></CONTAINER></AUTOSAR>